Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-08-21T17:43:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Aug 21 17:43:00 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{1E6748A0-55B1-4F47-93F3-7DF05E62EBB1}\ifc * Database version: 5507 * Database creation date: Wed Aug 21 17:43:00 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Aug 21 17:43:00 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Aug 21 17:43:00 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 434 Hand shower set, 434(2017):434 Hand shower set:384952
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions(Type) - NominalDepth: 85.8 mm; NominalHeight: 411.7 mm; NominalWidth: 123.4 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 434(2017); ConvergoRefNr: 0087-1909-0073-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 22/07/2019
Type - Green Building Properties(Type) - Customs Code: 39249000; EAN Number: 6414150080531; EN Standard: EN 1112; LVI Number: 6510200; NRF Number: 4205005; RSK Number: 8320147; VVS Number: 737596224
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/434; Catalog Drawing URL: http://static.oras.com/catdrw/434; Dimension Drawing URL: http://static.oras.com/dimdrw/434; FDV Document URL: http://www.oras.com/datasheet/434/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/434; Group: Hand showers and shower sets; Long Marketing: Oras Hydractiva Style hand shower set including 1-spray hand shower, wall bracket and 1500 mm shower hose. Hand shower with Sensitive spray (large & gently). With limescale protection tecnology. Max. flow rate 15 l/min (3 bar). White spray face, shower head size 110 mm x 120 mm.; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 434 Hand shower set; Name_en: 434 Hand shower set; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 380 x 180 x 74; Package Weight: 0.782 kg; Product Code: 434; Product Datasheet: http://www.oras.com/datasheet/434/en; Product Family: Oras Hydractiva; Product Image URL: http://static.oras.com/image/434; Product URL: http://static.oras.com/434; Type Name: 434 Hand shower set
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: G1/2; Flow Rate At 300kPa With Flow Controller: 0.00882867 m3/s; Hand Shower Size: 108 x 120 mm; Installation and Maintenance: http://static.oras.com/manual/434; Installation Type: Wall mounted; Max. Hot Water Supply: 65 kg/K/s3; Shower Parts: Shower holder;Hand shower;Shower Hose (1500 mm); Shower Spray: Sensitive; Shower Spray Number: 1 spray
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 434(2017); Features: n/a; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 434; Name: 434 Hand shower set; ReplacementCost: n/a; Shape: Sculptured; Size: 125x85x410 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 434; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 434 Hand shower set
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.0971869 m2; Volume: 0.00438343 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 434(2017): 434 Hand shower set; Family and Type: 434(2017): 434 Hand shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 434(2017): 434 Hand shower set; Type Id: 434(2017): 434 Hand shower set; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
